# Keil uVision project Bat.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c ClockConfig.c ClockConfig.h Delay.c Delay.h ADC.c ADC.h UART.c UART.h RingBuffer.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
